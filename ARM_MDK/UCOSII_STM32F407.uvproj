# Keil uVision project UCOSII_STM32F407.uvproj, settings and files
target UCOSII_STM32F407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOSII_STM32F407 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\BSP;..\STM32_StdPeriph_Library\CMSIS\CoreSupport;..\STM32_StdPeriph_Library\CMSIS\DeviceSupport\ST\STM32F4xx;..\STM32_StdPeriph_Library\STM32F4xx_StdPeriph_Driver\inc;..\UCOSII\Source;..\STM32_StdPeriph_Library\STM32F4XX_CONF_H;..\UCOSII\RealView;..\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSII\uC-LIB;..\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSII\uC-CPU;..\UCOSII
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../STM32_StdPeriph_Library/CMSIS/DeviceSupport/ST/STM32F4xx/startup/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../STM32_StdPeriph_Library/CMSIS/DeviceSupport/ST/STM32F4xx/: system_stm32f4xx.c
  group STM32_StdPeriph_Library
    ../STM32_StdPeriph_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c
  group uCOS/CPU
    ../UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
    ../UCOSII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uCOS/LIB
    ../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS/Port
    ../UCOSII/RealView/: os_cpu_c.c os_cpu_a.asm
  group uCOS/Src
    ../UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Bsp
    ../BSP/: bsp.c led.c stm32f4xx_it.c
  group Main
    ../Main/: main.c
    ../UCOSII/: app_hooks.c
  group Readme
    ../Readme/: Readme.txt
